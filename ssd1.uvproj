# Keil uVision project ssd1.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ssd1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Source Group 1
    ./: STARTUP.A51 main.c
